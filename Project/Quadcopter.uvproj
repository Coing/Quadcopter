# Keil uVision project Quadcopter.uvproj, settings and files
target Quadcopter (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Quadcopter +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\App;..\Bsp;..\Lib\FWlib\inc;..\Lib\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ../Lib/CMSIS/startup/: startup_stm32f10x_md.s
  group Quadcopter_Control
    ../App/: main.c stm32f10x_it.c Parameters.c Parameters.h RC.c RC.h control_stabilize.c control_stabilize.h altitude.c altitude.h
  group Quadcopter_Hal
    ../Bsp/: bsp.c bsp.h led.c led.h usart.c usart.h Moto.c moto.h timer.c timer.h Data_Transfer.c Data_Transfer.h i2cdev.c i2cdev.h i2croutines.c i2croutines.h nvicconf.h PPM.c PPM.h
  group Quadcopter_Sensors
    ../Bsp/: mpu6050.c mpu6050.h hmc5883l.c hmc5883l.h ms5611.c ms5611.h hcsr04.c hcsr04.h
  group Quadcopter_Algorithms
    ../Bsp/: imu.c imu.h Arhs.c arhs.h arhs_types.h filter.c filter.h
    ../App/: pid.c pid.h
  group Quadcopter_System
    ../Bsp/: stm32f1_system.c stm32f1_system.h SysTickTime_measure.c SysTickTime_measure.h
    ../App/: STM32_DELAY.c STM32_DELAY.h
  group ST_Lib
    ../Lib/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../Lib/CMSIS/: core_cm3.c system_stm32f10x.c stm32f10x.h system_stm32f10x.h
